# Keil uVision project ow_ds18b20_RTOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ow_ds18b20_RTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=8000000,STM32F429xx,USE_FULL_LL_DRIVER
  c include: ..\..\..\..\libs\st_hal\STM32F4xx_HAL_Driver\Inc;..\..\..\..\libs\FreeRTOS\include;..\..\..\..\libs\FreeRTOS\CMSIS_RTOS;../../../../snippets/include;../../../../libs/st_hal/CMSIS/Device/ST/STM32F4xx/Include;../../../../libs/st_hal/CMSIS/Include;../../../../libs;../inc;../../../../libs/FreeRTOS/portable/RVDS/ARM_CM4F;../../../../onewire_uart/src/include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK-ARM
    ./: startup_stm32f429xx.s
  group STM32F4xx_HAL_Driver
    ../../../../libs/st_hal/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_dma.c stm32f4xx_ll_exti.c stm32f4xx_ll_gpio.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_usart.c stm32f4xx_ll_utils.c
  group FreeRTOS
    ../../../../libs/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../libs/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../../../../libs/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../libs/FreeRTOS/CMSIS_RTOS/: cmsis_os.c cpu_utils.c
  group OW
    ../../../../onewire_uart/src/ow/: ow.c
  group OW DEVICES
    ../../../../onewire_uart/src/devices/: ow_device_ds18x20.c
  group OW LL
    ../../../../onewire_uart/src/system/: ow_ll_stm32f429zi_nucleo.c ow_sys_cmsis_os.c
  group OW SNIPPETS
    ../../../../snippets/: scan_devices.c
  group User
    ../src/: main.c stm32f4xx_it.c system_stm32f4xx.c
